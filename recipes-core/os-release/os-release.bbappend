OS_RELEASE_FIELDS += "MACHINE_ID VARIANT"
MACHINE_ID = "${MACHINE}"
